# Keil uVision project Pubnub_ATT_IoT_SK_WNC_sync.uvprojx, settings and files
target Pubnub_ATT_IoT_SK_WNC_sync (ARM-ADS)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.pdsc
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: Pubnub_ATT_IoT_SK_WNC_sync
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DTARGET_KPSDK_CODE --split_sections -D__ASSERT_MSG -DTARGET_RELEASE -DTARGET_MCU_K64F --no_rtti -DARM_MATH_CM4 -DFEATURE_IPV4=1 -DDEVICE_PORTINOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DDEVICE_SERIAL=1 -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -D__CORTEX_M4 -DDEVICE_ERROR_RED=1 -DTARGET_CORTEX_M -DDEVICE_ANALOGIN=1 -DTARGET_KPSDK_MCUS -DTARGET_Freescale -DTARGET_K64F -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_PORTIN=1 -DDEVICE_LOWPOWERTIMER=1 -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DMBED_BUILD_TIMESTAMP=1490757118.11 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DTARGET_FRDM -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu --apcs=interwork -DDEVICE_SPI=1 -DMBEDTLS_ENTROPY_HARDWARE_ALT -D__MBED__=1 -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DTARGET_M4 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DFSL_RTOS_MBED -D__MBED_CMSIS_RTOS_CM
  c include: .; Pubnub_mbed2_sync; Pubnub_mbed2_sync/Pubnub_c_core_mbed2_pal; Pubnub_mbed2_sync/Pubnub_c_core_mbed2_pal/Pubnub_c_core; WNCInterface; WNCInterface/Sms; WNCInterface/Socket; WNCInterface/WncControllerK64F; WNCInterface/WncControllerK64F/MODSERIAL; WNCInterface/WncControllerK64F/MODSERIAL/Device; WNCInterface/WncControllerK64F/WncController; mbed-rtos; mbed-rtos/rtos; mbed-rtos/rtx; mbed-rtos/rtx/TARGET_CORTEX_M; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7; mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM; mbed/.; mbed/TARGET_K64F; mbed/TARGET_K64F/TARGET_Freescale; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/TARGET_FRDM; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/drivers; mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/api; mbed/TARGET_K64F/TOOLCHAIN_ARM_STD;
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED,-DMBEDTLS_ENTROPY_HARDWARE_ALT
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/MK64FN1M0xxx12.sct
  group mbed
    mbed/: AnalogIn.h analogin_api.h AnalogOut.h analogout_api.h buffer.h BusIn.h BusInOut.h BusOut.h Callback.h CallChain.h CAN.h can_api.h can_helper.h CircularBuffer.h critical.h CThunk.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h dma_api.h Driver_Common.h Driver_Storage.h Ethernet.h ethernet_api.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FunctionPointer.h gpio_api.h gpio_irq_api.h I2C.h i2c_api.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h lp_ticker_api.h mbed.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h pinmap.h platform.h PlatformMutex.h port_api.h PortIn.h PortInOut.h PortOut.h PwmOut.h pwmout_api.h RawSerial.h rtc_api.h rtc_time.h semihost_api.h Serial.h serial_api.h SerialBase.h SingletonPtr.h sleep_api.h SPI.h spi_api.h SPISlave.h Stream.h Ticker.h ticker_api.h Timeout.h Timer.h TimerEvent.h toolchain.h Transaction.h us_ticker_api.h wait_api.h
    mbed/TARGET_K64F/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis.h cmsis_nvic.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.h
    mbed/TARGET_K64F/TOOLCHAIN_ARM_STD/: cmsis_nvic.o mbed.ar mbed_board.o mbed_overrides.o retarget.o startup_MK64F12.o sys.o system_MK64F12.o
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: crc.h device.h fsl_clock_config.h fsl_phy.h PeripheralNames.h PinNames.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/drivers/: fsl_adc16.h fsl_clock.h fsl_cmp.h fsl_cmt.h fsl_common.h fsl_crc.h fsl_dac.h fsl_dmamux.h fsl_dspi.h fsl_dspi_edma.h fsl_edma.h fsl_enet.h fsl_ewm.h fsl_flash.h fsl_flexbus.h fsl_flexcan.h fsl_ftm.h fsl_gpio.h fsl_i2c.h fsl_i2c_edma.h fsl_llwu.h fsl_lptmr.h fsl_mpu.h fsl_pdb.h fsl_pit.h fsl_pmc.h fsl_port.h fsl_rcm.h fsl_rnga.h fsl_rtc.h fsl_sai.h fsl_sai_edma.h fsl_sdhc.h fsl_sim.h fsl_smc.h fsl_uart.h fsl_uart_edma.h fsl_vref.h fsl_wdog.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/api/: gpio_object.h objects.h PeripheralPins.h PortNames.h
    mbed/TARGET_K64F/TARGET_Freescale/TARGET_KSDK2_MCUS/TARGET_MCU_K64F/: peripheral_clock_defines.h
  group mbed-rtos
    mbed-rtos/rtx/TARGET_CORTEX_M/: cmsis_os.h HAL_CM.c rt_CMSIS.c rt_Event.c rt_Event.h rt_HAL_CM.h rt_List.c rt_List.h rt_Mailbox.c rt_Mailbox.h rt_MemBox.c rt_MemBox.h rt_Memory.c rt_Memory.h rt_Mutex.c rt_Mutex.h rt_OsEventObserver.c rt_OsEventObserver.h rt_Robin.c rt_Robin.h rt_Semaphore.c rt_Semaphore.h rt_System.c rt_System.h rt_Task.c rt_Task.h rt_Time.c rt_Time.h rt_Timer.c rt_Timer.h rt_TypeDef.h RTX_CM_lib.h RTX_Conf_CM.c RTX_Config.h
    mbed-rtos/rtx/TARGET_CORTEX_M/TARGET_RTOS_M4_M7/TOOLCHAIN_ARM/: HAL_CM4.c SVC_Table.S
    mbed-rtos/rtos/: Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.c rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
  group Pubnub_ATT_IoT_SK_WNC_sync
    ./: main.cpp mbed_config.h pubnub_config.h
  group Pubnub_mbed2_sync
    Pubnub_mbed2_sync/Pubnub_c_core_mbed2_pal/Pubnub_c_core/: pbntf_trans_outcome_common.h pbpal.h pubnub_alloc.h pubnub_alloc_std.cpp pubnub_api_types.h pubnub_assert.h pubnub_assert_std.cpp pubnub_blocking_io.cpp pubnub_blocking_io.h pubnub_ccore.cpp pubnub_ccore.h pubnub_coreapi.cpp pubnub_coreapi.h pubnub_generate_uuid.cpp pubnub_generate_uuid.h pubnub_internal_common.h pubnub_json_parse.cpp pubnub_json_parse.h pubnub_log.h pubnub_memory_block.h pubnub_mutex.h pubnub_netcore.cpp pubnub_netcore.h pubnub_timers.cpp pubnub_timers.h pubnub_version.h
    Pubnub_mbed2_sync/Pubnub_c_core_mbed2_pal/: pbpal_mbed2_blocking_io.cpp pbpal_mutex.h pbpal_resolv_and_connect_mbed2.cpp pbpal_sockets.cpp pubnub_generate_uuid_v4_random_std.cpp pubnub_internal.h pubnub_version_mbed.cpp
    Pubnub_mbed2_sync/: pubnub_ntf_sync.cpp pubnub_ntf_sync.h pubnub_sync.h srand_from_pubnub_time.cpp srand_from_pubnub_time.h
  group WNCInterface
    WNCInterface/WncControllerK64F/MODSERIAL/Device/: AddingDevice.h MODSERIAL_KL05Z.cpp MODSERIAL_KL05Z.h MODSERIAL_KL25Z.cpp MODSERIAL_KL25Z.h MODSERIAL_KSDK.cpp MODSERIAL_KSDK.h MODSERIAL_LPC11U24.cpp MODSERIAL_LPC11U24.h MODSERIAL_LPC1768.cpp MODSERIAL_LPC1768.h MODSERIAL_NUCLEO_F401RE.cpp MODSERIAL_NUCLEO_F401RE.h MODSERIAL_PAC_F401RB.cpp MODSERIAL_PAC_F401RB.h
    WNCInterface/WncControllerK64F/MODSERIAL/: ChangeLog.c example1.cpp example2.cpp example3a.cpp example3b.cpp FLUSH.cpp GETC.cpp INIT.cpp ISR_RX.cpp ISR_TX.cpp MACROS.h MODSERIAL.cpp MODSERIAL.h MODSERIAL_IRQ_INFO.cpp PUTC.cpp RESIZE.cpp
    WNCInterface/Socket/: Endpoint.cpp Endpoint.h Socket.cpp Socket.h TCPSocketConnection.cpp TCPSocketConnection.h UDPSocket.cpp UDPSocket.h
    WNCInterface/Sms/: IOTSMS.cpp IOTSMS.h SMS.h
    WNCInterface/WncControllerK64F/WncController/: WncController.cpp WncController.h
    WNCInterface/WncControllerK64F/: WncControllerK64F.cpp WncControllerK64F.h
    WNCInterface/: WNCInterface.cpp WNCInterface.h
